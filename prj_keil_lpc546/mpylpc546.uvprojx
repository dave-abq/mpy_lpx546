# Keil uVision project mpylpc546.uvprojx, settings and files
target debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0
  cpu: IROM(0x00000000,0x00080000) IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mpynxp_lpc546
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N_THUMB,NDEBUG,CPU_LPC54608J512BD208,MCU_SERIES_LPC546,STM32_HAL_H='<stm32f4xx_hal.h>',__BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__,MICROPY_QSTR_EXTRA_POOL=mp_qstr_frozen_const_pool,MICROPY_MODULE_FROZEN_MPY,FFCONF_H='\"oofatfs/ffconf.h\"',HARD_FP
  c misc: --gnu --diag_suppress=61,68,111,546,188,1035,144,1211,1295 --no_inline
  c include: ..\;..\py;..\extmod;..\lib;..\lib\cmsis\inc;..\nxp_lpc546;..\nxp_lpc546\boards\lpx54608;..\nxp_lpc546\sdk22\;..\nxp_lpc546\sdk22\drivers;..\nxp_lpc546\sdk22\utilities;..\nxp_lpc546\cmsis;..\nxp_lpc546\build-lpx54608;..\nxp_lpc546\usbdev\core\inc;..\nxp_lpc546\usbdev\class\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\flash.sct
  group prebuilt
    ./out_mpylib/: lib_mpy.lib
  group py
    ../py/: argcheck.c asmbase.c asmthumb.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c emitbc.c emitcommon.c emitglue.c emitinlinethumb.c emitnative.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c moduerrno.c mpprint.c mpstate.c mpz.c nativeglue.c nlrsetjmp.c nlrthumb.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcomplex.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c opmethods.c parse.c parsenum.c parsenumbase.c persistentcode.c qstr.c reader.c repl.c runtime.c runtime_utils.c scheduler.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c asmbase.h asmthumb.h bc.h bc0.h binary.h builtin.h compile.h emit.h emitglue.h formatfloat.h frozenmod.h gc.h grammar.h lexer.h misc.h mpconfig.h mperrno.h mphal.h mpprint.h mpstate.h mpthread.h mpz.h nlr.h obj.h objarray.h objexcept.h objfun.h objgenerator.h objint.h objlist.h objmodule.h objstr.h objstringio.h objtuple.h objtype.h parse.h parsenum.h parsenumbase.h persistentcode.h qstr.h qstrdefs.h reader.h repl.h ringbuf.h runtime.h runtime0.h scope.h smallint.h stackctrl.h stream.h unicode.h vmentrytable.h asmarm.c asmx64.c asmx86.c asmxtensa.c nlrx64.c nlrx86.c nlrxtensa.c
  group lib_libc
    ../lib/libc/: string0.c
  group lib_libm
    ../lib/libm/: acoshf.c asinfacosf.c asinhf.c atan2f.c atanf.c atanhf.c ef_rem_pio2.c ef_sqrt.c erf_lgamma.c fmodf.c kf_cos.c kf_rem_pio2.c kf_sin.c kf_tan.c log1pf.c math.c nearbyintf.c roundf.c sf_cos.c sf_erf.c sf_frexp.c sf_ldexp.c sf_modf.c sf_sin.c sf_tan.c thumb_vfp_sqrtf.c wf_lgamma.c wf_tgamma.c fdlibm.h libm.h
  group lib_misc
    ../lib/oofatfs/: ff.c ff.h diskio.h ffconf.h
    ../lib/oofatfs/option/: ccsbcs.c unicode.c
    ../lib/mp-readline/: readline.c
    ../lib/netutils/: netutils.c netutils.h
    ../lib/timeutils/: timeutils.c timeutils.h
    ../lib/utils/: interrupt_char.c pyexec.c printf.c interrupt_char.h pyexec.h
  group extmod
    ../extmod/: machine_i2c.c machine_mem.c machine_pinbase.c machine_pulse.c machine_signal.c machine_spi.c modbtree.c modframebuf.c modubinascii.c moductypes.c moduhashlib.c moduheapq.c modujson.c modurandom.c modure.c moduselect.c modussl_axtls.c modussl_mbedtls.c modutimeq.c moduzlib.c modwebrepl.c modwebsocket.c uos_dupterm.c utime_mphal.c vfs.c vfs_fat.c vfs_fat_diskio.c vfs_fat_file.c vfs_fat_misc.c vfs_reader.c virtpin.c
  group stm32f4_hal
    ../nxp_lpc546/hal/f4/src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
    ../nxp_lpc546/hal/f4/inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cortex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_spi.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group stm32_usb
    ../nxp_lpc546/usbdev/core/src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../nxp_lpc546/usbdev/core/inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
    ../nxp_lpc546/usbdev/class/src/: usbd_cdc_msc_hid.c usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../nxp_lpc546/usbdev/class/inc/: usbd_cdc_msc_hid.h usbd_cdc_msc_hid0.h usbd_msc_bot.h usbd_msc_data.h usbd_msc_scsi.h
  group build_lpx546
    ../nxp_lpc546/build-lpx54608/: frozen_mpy.c pins_lpx54608.c pins_qstr.h modmcu_qstr.h
    ../nxp_lpc546/build-lpx54608/genhdr/: modmcu_const.h
  group port
    ../nxp_lpc546/: startup_LPC54608.s gchelper_armccv5.S bufhelper.c extint.c fatfs_port.c flash.c gccollect.c help.c irq.c led.c main.c modmachine.c modnetwork.c modpyb.c modmcu.c moduos.c modusocket.c modutime.c mphalport.c mpthreadport.c pendsv.c pin.c pin_named_pins.c pybstdio.c pybthread.c rng.c rtc.c sdcard.c servo.c spi.c storage.c systick.c timer.c uart.c usb.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c usbd_hid_interface.c usbd_msc_storage.c usrsw.c wdt.c startup_stm32.S startup_stm32f405xx.S accel.h adc.h bufhelper.h can.h dac.h dma.h extint.h flash.h font_petme128_8x8.h gccollect.h i2c.h irq.h lcd.h led.h makeout.txt modmachine.h modnetwork.h mpconfigport.h mphalport.h mpthreadport.h pendsv.h pin.h pin_defs_nxp_lpc546.h portmodules.h pybthread.h qstrdefsport.h rng.h rtc.h sdcard.h servo.h spi.h stm32_it.h storage.h systick.h timer.h uart.h unistd.h usb.h usbd_cdc_interface.h usbd_conf.h usbd_desc.h usbd_hid_interface.h usbd_msc_storage.h usrsw.h wdt.h hal_wrapper.c hal_wrapper.h pin_defs_lpc546.c pin_defs_lpc546.h
  group SDK22
    ../nxp_lpc546/sdk22/drivers/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_eeprom.c fsl_emc.c fsl_enet.c fsl_flashiap.c fsl_flexcomm.c fsl_fmc.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_lcdc.c fsl_mcan.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rit.c fsl_rtc.c fsl_sctimer.c fsl_sdif.c fsl_spi.c fsl_spi_dma.c fsl_spi_freertos.c fsl_spifi.c fsl_spifi_dma.c fsl_usart.c fsl_usart_dma.c fsl_usart_freertos.c fsl_utick.c fsl_wwdt.c
    ../nxp_lpc546/sdk22/utilities/: fsl_debug_console.c
    ../nxp_lpc546/sdk22/: system_LPC54608.c
    ../nxp_lpc546/sdk22/arm/: keil_lib_power.lib
  group Board
    ../nxp_lpc546/boards/lpx54608/: board.c clock_config.c pin_mux.c board.h clock_config.h pin_mux.h
target lib_py (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: lib_mpy (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=2
  c define: N_THUMB,NDEBUG,STM32F405xx,MCU_SERIES_F4,STM32_HAL_H='<stm32f4xx_hal.h>',__BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__,MICROPY_QSTR_EXTRA_POOL=mp_qstr_frozen_const_pool,MICROPY_MODULE_FROZEN_MPY,FFCONF_H='\"ffconf.h\"',HARD_FP
  c misc: --gnu --diag_suppress=61,68,111,546,188,1035,144,1211,39,222
  c include: ..\;..\py;..\extmod;..\lib;..\nxp_lpc546;..\nxp_lpc546\boards\PYBV11;..\nxp_lpc546\hal\f4\inc;..\nxp_lpc546\cmsis;..\nxp_lpc546\build-PYBV11;..\lib\cmsis\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: Compiler:I/O:STDERR 1.0.0, Compiler:I/O:STDIN 1.0.0, Compiler:I/O:STDOUT 1.0.0
